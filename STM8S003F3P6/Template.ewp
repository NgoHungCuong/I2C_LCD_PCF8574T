# IAR project Template.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S003
  ICCSTM8.CCIncludePath2: ; ..\..\STM8S_StdPeriph_Lib_V2.1.0\Libraries\STM8S_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: Template.s19
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group StdLib
    ../../STM8S_StdPeriph_Lib_V2.1.0/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
  group User
    ./: I2C_LCD.c I2C_LCD.h i2c_lcd_hw_cfg.h main.c Soft_I2C.c Soft_I2C.h stm8s_conf.h stm8s_it.c
