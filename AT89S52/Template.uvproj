# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./User/: main.c
